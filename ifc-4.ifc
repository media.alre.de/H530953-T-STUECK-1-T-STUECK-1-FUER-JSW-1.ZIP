Properties of the parts of a building model (IFC4)

# File
Description: T-Stück 1" für JSW-1, Messing vernickelt, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H530953, T-Stück 1" für JSW-1, Messing vernickelt
In: Raum
Description: T-Stück 1" für Strömungswächter JSW-1, Messing vernickelt; Classification: EC010123 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H530953; ModelLabel: T-Stück 1"; GlobalTradeItemNumber: 4050528044839; ProductURL: https://alre.de/produkt_H530953
Pset_Specification - NominalLength: 0.053 m; NominalWidth: 0.05 m; NominalDepth: 0.0395 m; NetWeight: 0.196
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC010123; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H530953.pdf
